# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: .\FWLIB\inc;.\CMSIS;.\User;.\System;.\BSP\i2c;.\BSP\Key;.\BSP\LCD;.\BSP\seiral;.\BSP\spi;.\BSP\TOUCH;.\Freertos\inc;.\Freertos\port;.\Freertos\stc;.\BSP\tim;.\LVGL\GUI;.\LVGL\GUI\lvgl\src;.\LVGL\GUI\porting;.\LVGL\GUI\lvgl;.\User\GUI_App;.\User\GUI_App\Screens\Inc;.\User\Func\Inc;.\User\Func\Src;.\LVGL\GUI\lvgl\src\hal;.\BSP\rtc;.\User\task
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./User/: main.c main.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group CMSIS
    ./CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h startup_stm32f411xe.s stm32f4xx.h system_stm32f4xx.h core_cm4.h
  group FWLIB
    ./FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    ./System/: Delay.h Delay.c
  group BSP/LCD
    ./BSP/LCD/: lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h pic.h ST7789.txt
  group BSP/spi
    ./BSP/spi/: MYSPI.c MYSPI.h
  group BSP/serial
    ./BSP/seiral/: Serial.c Serial.h
  group BSP/TOUCH
    ./BSP/TOUCH/: CST816.c CST816.h
  group BSP/i2c
    ./BSP/i2c/: myi2c.c myi2c.h
  group BSP/tim
    ./BSP/tim/: tim.c tim.h
  group freertos/inc
    ./Freertos/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h FreeRTOSConfig.h
  group freertos/port
    ./Freertos/port/: heap_4.c port.c portmacro.h
  group freertos/stc
    ./Freertos/stc/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group User/task
    ./User/task/: user_HardwareInitTask.c user_HardwareInitTask.h user_KeyTask.c user_KeyTask.h user_MessageSendTask.c user_MessageSendTask.h user_RunModeTasks.c user_RunModeTasks.h user_ScrRenewTask.c user_ScrRenewTask.h user_TasksInit.c user_TasksInit.h
  group LVGL/GUI\lvgl/src/core
    ./LVGL/GUI/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group LVGL/GUI\lvgl/src/draw
    ./LVGL/GUI/lvgl/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h
    ./LVGL/GUI/lvgl/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c lv_gpu_nxp_vglite.h
    ./LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h
    ./LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
    ./LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ./LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group LVGL/GUI\lvgl/src/extra
    ./LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
    ./LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
    ./LVGL/GUI/lvgl/src/extra/layouts/: lv_layouts.h
    ./LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ./LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./User/GUI_App/IMGs/: ui_img_compass_needle_png.c
    ./LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
    ./LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
    ./LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c lv_freetype.h
    ./LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
    ./LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
    ./LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
    ./LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.c qrcodegen.h
    ./LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.h
    ./LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
    ./LVGL/GUI/lvgl/src/extra/libs/: lv_libs.h
  group LVGL/GUI\lvgl/src/font
    ./LVGL/GUI/lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_symbol_def.h
  group LVGL/GUI\lvgl/src/misc
    ./LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group LVGL/GUI\lvgl/src/widgets
    ./LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
  group LVGL/GUI
    ./LVGL/GUI/lvgl/: lvgl.h
    ./LVGL/GUI/: lv_conf.h
    ./LVGL/GUI/lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group LVGL/porting
    ./LVGL/GUI/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group User/GUI_APP
    ./User/GUI_App/: ui.c ui.h ui_helpers.c ui_helpers.h
    ./User/GUI_App/Screens/Inc/: ui_AboutPage.h ui_CalendarPage.h ui_ChargPage.h ui_CompassPage.h ui_ComputerPage.h ui_DateTimeSetPage.h ui_EnvPage.h ui_Game2048Page.h ui_GameMemPage.h ui_GameSelectPage.h ui_HomePage.h ui_HRPage.h ui_Megboxes.h ui_MenuPage.h ui_NFCCardPage.h ui_OffTimePage.h ui_SetPage.h ui_SPO2Page.h ui_TimerPage.h
    ./User/GUI_App/Screens/Src/: ui_AboutPage.c ui_CalendarPage.c ui_ChargPage.c ui_CompassPage.c ui_ComputerPage.c ui_DateTimeSetPage.c ui_EnvPage.c ui_Game2048Page.c ui_GameMemPage.c ui_GameSelectPage.c ui_HomePage.c ui_HRPage.c ui_Megboxes.c ui_MenuPage.c ui_NFCCardPage.c ui_OffTimePage.c ui_SetPage.c ui_SPO2Page.c ui_TimerPage.c
    ./User/GUI_App/Fonts/: ui_font_Cuyuan18.c ui_font_Cuyuan20.c ui_font_Cuyuan24.c ui_font_Cuyuan30.c ui_font_Cuyuan38.c ui_font_Cuyuan48.c ui_font_Cuyuan80.c ui_font_Cuyuan100.c ui_font_iconfont16.c ui_font_iconfont24.c ui_font_iconfont28.c ui_font_iconfont30.c ui_font_iconfont32.c ui_font_iconfont34.c ui_font_iconfont45.c
  group User/Func
    ./User/Func/Inc/: HWDataAccess.h PageManager.h pubsub.h StrCalculate.h
    ./User/Func/Src/: HWDataAccess.c PageManager.c pubsub.c StrCalculate.c
  group LVGL/GUI/lvgl/stc/hal
    ./LVGL/GUI/lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group BSP/rtc
    ./BSP/rtc/: rtc.c rtc.h
  group BSP/Key
    ./BSP/Key/: Key.c Key.h
